# Keil uVision project Project.uvprojx, settings and files
target STM32F723E-Discovery (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F723IEKx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x8000000-0x807FFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32F723E-Discovery
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F723xx,USE_STM32F723E_DISCO,TS_MULTI_TOUCH_SUPPORTED
  c misc: --C99
  c include: ../Inc;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/BSP/STM32F723E-Discovery;../Drivers/BSP/Components/Common;../Utilities/Log;../Utilities/Fonts;../Utilities/CPU;../Inc/layers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Doc
    ../: readme.txt
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_gpio.c stm32f7xx_hal_uart.c stm32f7xx_hal_pwr.c stm32f7xx_hal.c stm32f7xx_hal_rcc.c stm32f7xx_hal_qspi.c stm32f7xx_hal_cortex.c stm32f7xx_hal_sram.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_i2c.c stm32f7xx_ll_fmc.c stm32f7xx_hal_dma.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_dma_ex.c
  group Drivers/BSP/STM32F723E_DISCOVERY
    ../Drivers/BSP/STM32F723E-Discovery/: stm32f723e_discovery_ts.c stm32f723e_discovery_audio.c stm32f723e_discovery_psram.c stm32f723e_discovery_qspi.c stm32f723e_discovery_lcd.c stm32f723e_discovery.c
  group Example/User
    ../Src/: main.c stm32f7xx_it.c ts_calibration.c lcd.c psram.c qspi.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/wm8994/: wm8994.c
    ../Drivers/BSP/Components/st7789h2/: st7789h2.c
    ../Drivers/BSP/Components/ft6x06/: ft6x06.c
  group Example/Utilities
    ../Utilities/Log/: lcd_log.c
  group Example/MDK-ARM
    ./: startup_stm32f723xx.s
  group NNoM
    ../Src/backends/: nnom_local.c nnom_local_q15.c
    ../Src/core/: nnom.c nnom_layers.c nnom_tensor.c nnom_utils.c
    ../Src/layers/: nnom_activation.c nnom_avgpool.c nnom_baselayer.c nnom_concat.c nnom_conv2d.c nnom_conv2d_trans.c nnom_cropping.c nnom_dense.c nnom_dw_conv2d.c nnom_flatten.c nnom_global_pool.c nnom_gru_cell.c nnom_input.c nnom_lambda.c nnom_lstm_cell.c nnom_matrix.c nnom_maxpool.c nnom_output.c nnom_rnn.c nnom_simple_cell.c nnom_softmax.c nnom_sumpool.c nnom_upsample.c nnom_zero_padding.c
software components: CMSIS:CORE 5.4.0, CMSIS:DSP 1.8.0, CMSIS:NN Lib 1.3.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
